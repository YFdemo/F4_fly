# Keil uVision project yiyi.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: yiyi +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\lib;..\start;..\user;..\system;..\interface;..\hardware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./: main.c
  group start
    ../start/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c stm32f10x_it.c
  group lib
    ../lib/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group system
    ../system/: delay.c sys.c control.c pwm_out.c
  group interface
    ../interface/: usart.c IIC.c IMU.c
  group hardware
    ../hardware/: timer.c mpu6050.c
